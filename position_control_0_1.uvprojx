# Keil uVision project position_control_0_1.uvprojx, settings and files
target FRDM-KL46Z256 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: position_control_0_1
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM0PLUS
  c include: .\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Inc
    ./Inc/: acc.h adafruit_modul.h adc16.h bluetooth_connection.h buzzer.h common.h controller.h dataTypes.h debug.h dma.h extended_math.h filter.h gyro.h i2c.h interrupt.h kalman_filter.h led.h lptmr.h mag.h main.h mcg.h MKL46Z4.h pwm.h receiver.h sensor_fusion.h switches.h sysinit.h sysTick.h tpm.h TPM_o.h uart.h
    ./Src/: startup_MKL46Z4.s
  group Src
    ./Src/: acc.c adafruit_modul.c adc16.c bluetooth_connection.c buzzer.c controller.c debug.c dma.c extended_math.c filter.c gyro.c i2c.c interrupt.c io.c kalman_filter.c led.c lptmr.c mag.c main.c mcg.c pwm.c receiver.c Retarget.c sensor_fusion.c switches.c sysinit.c sysTick.c tpm.c TPM_o.c uart.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6
